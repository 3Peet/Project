/*
  Rui Santos
  Complete project details at Complete project details at https://RandomNerdTutorials.com/esp32-http-get-post-arduino/

  Permission is hereby granted, free of charge, to any person obtaining a copy
  of this software and associated documentation files.

  The above copyright notice and this permission notice shall be included in all
  copies or substantial portions of the Software.
*/

#include <WiFi.h>
#include <HTTPClient.h>
#include <Arduino_JSON.h>

const char* ssid = "RP4";
const char* password = "0852902000s";


//Your Domain name with URL path or IP address with path
const char* serverName = "http://192.168.1.111:3000/sw-light";

// the following variables are unsigned longs because the time, measured in
// milliseconds, will quickly become a bigger number than can be stored in an int.
unsigned long lastTime = 0;
// Timer set to 10 minutes (600000)
//unsigned long timerDelay = 600000;
// Set timer to 5 seconds (5000)
unsigned long timerDelay = 5000;

String sensorReadings;
float sensorReadingsArr[3];

void setup() {

  Serial.begin(115200);

  WiFi.begin(ssid, password);
  Serial.println("Connecting");
  while(WiFi.status() != WL_CONNECTED) {
    delay(500);
    Serial.print(".");
  }
  Serial.println("");
  Serial.print("Connected to WiFi network with IP Address: ");
  Serial.println(WiFi.localIP());
 
  Serial.println("Timer set to 5 seconds (timerDelay variable), it will take 5 seconds before publishing the first reading.");

  
}

void loop() {
  //Send an HTTP POST request every 10 minutes
  if ((millis() - lastTime) > timerDelay) {
    //Check WiFi connection status
    if(WiFi.status()== WL_CONNECTED){
              
      sensorReadings = httpGETRequest(serverName);
      //Serial.println(sensorReadings);
      JSONVar myObject = JSON.parse(sensorReadings);
  
      // JSON.typeof(jsonVar) can be used to get the type of the var
      if (JSON.typeof(myObject) == "undefined") {
        Serial.println("Parsing input failed!");
        return;
      }
    
 //     Serial.print("JSON object = ");
 //     Serial.println(myObject);
    
      // myObject.keys() can be used to get an array of all the keys in the object
      JSONVar keys = myObject.keys();
    
      for (int i = 0; i < keys.length(); i++) {
        JSONVar value = myObject[keys[i]];        
//        Serial.print(keys[i]);
//        Serial.print(" = ");
//        Serial.println(value);
        if (i==2 ){          
//          Serial.print(keys[i]);
//          Serial.print(" = ");
            
            JSONVar light_status = value;
            JSONVar light_key = value.keys();
            
            Serial.println(light_status);

            Serial.print("JSON.typeof(light_status) = ");
            Serial.println(JSON.typeof(light_status));

            Serial.print("light_status.keys() = ");
            Serial.println(light_status.keys());

            for (int i = 0; i < light_key.length(); i++) {
              JSONVar value = light_status[keys[i]];
              Serial.print(light_key[i]);
              Serial.print(" = ");
              Serial.println(value);
              sensorReadingsArr[i] = double(value);
      }
              Serial.print("1 = ");
              Serial.println(sensorReadingsArr[0]);
              Serial.print("2 = ");
              Serial.println(sensorReadingsArr[1]);
              Serial.print("3 = ");
              Serial.println(sensorReadingsArr[2]);
          }
 
      }
        
        Serial.println("---------------------------------------------------------------");
//      Serial.println(sensorReadingsArr[3]);
//      Serial.print("1 = ");
//      Serial.println(sensorReadingsArr[0]);
//      Serial.print("2 = ");
//      Serial.println(sensorReadingsArr[1]);
//      Serial.print("3 = ");
//      Serial.println(sensorReadingsArr[2]);
    }
    else {
      Serial.println("WiFi Disconnected");
    }
    lastTime = millis();
  }
}

String httpGETRequest(const char* serverName) {
  HTTPClient http;
    
  // Your IP address with path or Domain name with URL path 
  http.begin(serverName);
  
  // Send HTTP POST request
  int httpResponseCode = http.GET();
  
  String payload = "{}"; 
  
  if (httpResponseCode>0) {
    Serial.print("HTTP Response code: ");
    Serial.println(httpResponseCode);
    payload = http.getString();
  }
  else {
    Serial.print("Error code: ");
    Serial.println(httpResponseCode);
  }
  // Free resources
  http.end();

  return payload;
}
